FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " file://custom_kernel_config.cfg"
